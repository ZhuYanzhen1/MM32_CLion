# Repository ZhuYanzhen1/MM32_CLion (continued)

## KiCad design circuit/control_board/project.kicad_pcb (continued)

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12: 100nF; C_0603_1608Metric
J1: BAT_CR1220
J2: ANT; SMA_Molex_73251-2200_Horizontal
L1: 39nH; L_0603_1608Metric
LCD1: 1.8inch-TFT-LCD; TFT-LCD1.8inch
R1: 1kR; R_0603_1608Metric
U1: TAU1201; ublox_NEO
U2: XPT2046TS; TSSOP-16_4.4x5mm_P0.65mm

Connections:
+3.3VA: C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, LCD1.4 (LED+), LCD1.10 (VCC), LCD1.11 (IOVCC); also elsewhere on the board
+3.3VP: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, U1.23 (VDD), U2.1 (VCC), U2.10 (IOVDD); also elsewhere on the board
/LCD&GPS/GPS_RX: U1.21 (UIN0); also elsewhere on the board
/LCD&GPS/GPS_TX: U1.20 (UOUT0); also elsewhere on the board
/LCD&GPS/LCD_A0: LCD1.7 (A0); also elsewhere on the board
/LCD&GPS/LCD_CLK: LCD1.9 (CLK); also elsewhere on the board
/LCD&GPS/LCD_CS: LCD1.12 (CS); also elsewhere on the board
/LCD&GPS/LCD_MOSI: LCD1.8 (DI); also elsewhere on the board
/LCD&GPS/LCD_RST: LCD1.6 (~RESET); also elsewhere on the board
/LCD&GPS/TOUCH_CLK: U2.16 (DCLK); also elsewhere on the board
/LCD&GPS/TOUCH_CS: U2.15 (~CS); also elsewhere on the board
/LCD&GPS/TOUCH_IT: U2.11 (~PENIRQ); also elsewhere on the board
/LCD&GPS/TOUCH_MISO: U2.12 (DOUT); also elsewhere on the board
/LCD&GPS/TOUCH_MOSI: U2.14 (DIN); also elsewhere on the board
/LCD&GPS/T_XM: LCD1.16 (X-), U2.4 (XN)
/LCD&GPS/T_XP: LCD1.18 (X+), U2.2 (XP)
/LCD&GPS/T_YM: LCD1.15 (Y-), U2.5 (YN)
/LCD&GPS/T_YP: LCD1.17 (Y+), U2.3 (YP)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, J1.2 (N), J2.2, LCD1.2 (GND), LCD1.3 (LED-), LCD1.5 (GND), LCD1.13 (GND), U1.10 (GND), U1.12 (GND), U1.13 (GND), U1.24 (GND), U2.6 (GND); also elsewhere on the board
unnamed: J1.1, R1.2
unnamed: J2.1, L1.2, U1.11 (RF_IN)
unnamed: L1.1, U1.9 (ANT_BIAS)
unnamed: R1.1, U1.22 (AVDD_BAK)

Notes on the sheet:
GPS
LCD

Parts:
C54, C55, C57, C58, C59, C60, C62, C63, C64, C65, C66, C67, C68: 100nF; C_0603_1608Metric
C56, C61: 18pF; C_0603_1608Metric
D2: LED; LED_0603_1608Metric
R5, R7: 10kR; R_0603_1608Metric
R6: 1kR; R_0603_1608Metric
U9: MM32F3277G9P; LQFP-144_20x20mm_P0.5mm
Y2: 8MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3VA: R6.1; also elsewhere on the board
+3.3VP: C54.1, C55.1, C57.1, C58.1, C59.1, C60.1, C62.1, C63.1, C64.1, C65.1, C67.1, C68.1, R7.1, U9.6 (VBAT), U9.17 (VDD), U9.32 (VREF+), U9.33 (VDDA), U9.39 (VDD), U9.52 (VDD), U9.62 (VDD), U9.72 (VDD), U9.84 (VDD), U9.95 (VDD), U9.108 (VDD), U9.121 (VDD), U9.131 (VDD), U9.144 (VDD); also elsewhere on the board
/Control_MCU/LED1: D2.1 (K), U9.36 (PA2)
/Control_MCU/PD10: U9.79 (PD10); also elsewhere on the board
/Control_MCU/RST: C66.1, R7.2, U9.25 (nRST)
/Control_MCU/SPI3_CLK: U9.81 (PD12); also elsewhere on the board
/Control_MCU/SPI3_MISO: U9.82 (PD13); also elsewhere on the board
/Control_MCU/SPI3_MOSI: U9.85 (PD14); also elsewhere on the board
/Control_MCU/SPI3_NSS: U9.86 (PD15); also elsewhere on the board
/Control_MCU/SWDCLK: U9.109 (PA14); also elsewhere on the board
/Control_MCU/SWDIO: U9.105 (PA13); also elsewhere on the board
/Control_MCU/TIM3_CH1: U9.134 (PB4); also elsewhere on the board
/Control_MCU/UART1_RX: U9.102 (PA10); also elsewhere on the board
/Control_MCU/UART1_TX: U9.101 (PA9); also elsewhere on the board
/Control_MCU/UART6_RX: U9.47 (PB1); also elsewhere on the board
/Control_MCU/UART6_TX: U9.46 (PB0); also elsewhere on the board
/Control_MCU/UART7_RX: U9.137 (PB7); also elsewhere on the board
/Control_MCU/UART7_TX: U9.136 (PB6); also elsewhere on the board
/Control_MCU/XTAL_IN: C61.1, U9.23 (PH0), Y2.3
/Control_MCU/XTAL_OUT: C56.1, U9.24 (PH1), Y2.1
GND: C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, R5.1, U9.16 (VSS), U9.30 (VSSA), U9.31 (VREF-), U9.38 (VSS), U9.51 (VSS), U9.61 (VSS), U9.71 (VSS), U9.83 (VSS), U9.94 (VSS), U9.107 (VSS), U9.120 (VSS), U9.130 (VSS), U9.143 (VSS), Y2.2, Y2.4; also elsewhere on the board
unnamed: D2.2 (A), R6.2
unnamed: R5.2, U9.138 (PH3)

Notes on the sheet:
LED
XTAL & RST
Filter

Parts:
C71: 4.7uF; C_0603_1608Metric
C72: 100nF; C_0603_1608Metric
J4: Conn_01x06; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
R9, R10: 10kR; R_0603_1608Metric
U11: AT24C02; SOP-8_3.9x4.9mm_P1.27mm

Connections:
+3.3VA: C72.1, R9.1, R10.1, U11.8 (VDD); also elsewhere on the board
+3.3VADC: C71.1, J4.1; also elsewhere on the board
/Compass&Storage/Compass_CLK: J4.5; also elsewhere on the board
/Compass&Storage/Compass_CS: J4.2; also elsewhere on the board
/Compass&Storage/Compass_MISO: J4.4; also elsewhere on the board
/Compass&Storage/Compass_MOSI: J4.3; also elsewhere on the board
/Compass&Storage/EEPROM_SCL: R10.2, U11.6 (SCL); also elsewhere on the board
/Compass&Storage/EEPROM_SDA: R9.2, U11.5 (SDA); also elsewhere on the board
GND: C71.2, C72.2, J4.6, U11.1 (A0), U11.2 (A1), U11.3 (A2), U11.4 (GND), U11.7 (WP); also elsewhere on the board

Notes on the sheet:
EEPROM
Compass

Parts:
C73: 100nF; C_0603_1608Metric
D3: LED; LED_0603_1608Metric
J5: Conn_01x04; SWD_Connector
R11, R12, R13, R14: 10kR; R_0603_1608Metric
R15: 1kR; R_0603_1608Metric
U12: MM32SPIN27PS; LQFP-64_10x10mm_P0.5mm

Connections:
+3.3VADC: J5.1, R12.1, R13.1, R14.1, R15.1, U12.13 (VDDA), U12.32 (VDD), U12.64 (VDD); also elsewhere on the board
/Compass&Storage/Compass_CLK: U12.21 (PA5); also elsewhere on the board
/Compass&Storage/Compass_CS: U12.20 (PA4); also elsewhere on the board
/Compass&Storage/Compass_MISO: U12.18 (PD4); also elsewhere on the board
/Compass&Storage/Compass_MOSI: U12.19 (PD5); also elsewhere on the board
/Coprocessor/IIC_CLK: R13.2, U12.56 (PB4); also elsewhere on the board
/Coprocessor/IIC_SDA: R12.2, U12.55 (PB3); also elsewhere on the board
/Coprocessor/LED1: D3.1 (K), U12.51 (PC10)
/Coprocessor/PC6: U12.37 (PC6); also elsewhere on the board
/Coprocessor/PC7: U12.38 (PC7); also elsewhere on the board
/Coprocessor/RST: C73.1, R14.2, U12.7 (nRST)
/Coprocessor/SPI2_CLK: U12.34 (PB13); also elsewhere on the board
/Coprocessor/SPI2_MISO: U12.35 (PB14); also elsewhere on the board
/Coprocessor/SPI2_MOSI: U12.36 (PB15); also elsewhere on the board
/Coprocessor/SPI2_NSS: U12.33 (PB12); also elsewhere on the board
/Coprocessor/SWDCLK: J5.3, U12.49 (PA14)
/Coprocessor/SWDIO: J5.2, U12.46 (PA13)
/Coprocessor/UART1_RX: U12.43 (PA10); also elsewhere on the board
/Coprocessor/UART1_TX: U12.42 (PA9); also elsewhere on the board
GND: C73.2, J5.4, R11.1, U12.12 (VSSA), U12.31 (VSS), U12.63 (VSS); also elsewhere on the board
unnamed: D3.2 (A), R15.2
unnamed: R11.2, U12.60 (BOOT0)

Notes on the sheet:
LED
RST

Parts:
C74, C75, C76: 100nF; C_0603_1608Metric
D4: LED; LED_0603_1608Metric
P1: USB_C_Plug_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
R16: 100kR; R_0603_1608Metric
R17: 4.7kR; R_0603_1608Metric
R18, R19: 10kR; R_0603_1608Metric
U13: GL823K; SSOP-16_3.9x4.9mm_P0.635mm
U14: CH440R; TSSOP-16_4.4x5mm_P0.65mm
U15, U16: CH443K; SOT-363_SC-70-6
U17: MKDV1GCL-AB; LGA-8060_8

Connections:
+3.3VP: R18.1, R19.1, U17.8 (Vin); also elsewhere on the board
+5V: P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS), R17.1, U13.10 (5V), U14.16 (VCC), U15.5 (VCC), U16.5 (VCC); also elsewhere on the board
/Control_MCU/PD10: U14.1 (SEL), U15.6 (SEL), U16.6 (SEL); also elsewhere on the board
/Control_MCU/SPI3_CLK: U14.10 (S2C); also elsewhere on the board
/Control_MCU/SPI3_MISO: U14.3 (S2A); also elsewhere on the board
/Control_MCU/SPI3_MOSI: U14.6 (S2B); also elsewhere on the board
/Control_MCU/SPI3_NSS: U14.13 (S2D); also elsewhere on the board
/Flash&USB/CLK: U13.4 (CLK), U14.11 (S1C)
/Flash&USB/CMD: U13.5 (CMD), U14.5 (S1B)
/Flash&USB/DATA0: U13.3 (D0), U14.2 (S1A)
/Flash&USB/DATA1: U13.2 (D1), U16.3 (CH0)
/Flash&USB/DATA2: U13.7 (D2), U15.3 (CH0)
/Flash&USB/DATA3: U13.6 (D3), U14.14 (S1D)
/Flash&USB/GL_DM: P1.A7 (D-), P1.B7 (D-), U13.16 (DM)
/Flash&USB/GL_DP: P1.A6 (D+), P1.B6 (D+), U13.15 (DP)
/Flash&USB/SD_CLK: U14.9 (DC), U17.3 (CLK)
/Flash&USB/SD_CMD: U14.7 (DB), U17.5 (CMD)
/Flash&USB/SD_D0: U14.4 (DA), U17.6 (DAT0)
/Flash&USB/SD_D1: U16.4 (COM), U17.7 (DAT1)
/Flash&USB/SD_D2: U15.4 (COM), U17.1 (DAT2)
/Flash&USB/SD_D3: U14.12 (DD), U17.2 (DAT3)
/Flash&USB/USB_VDD: C74.1, C75.1, C76.1, U13.9 (VDD), U13.13 (VDDA)
GND: C74.2, C75.2, C76.2, P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), R16.2, U13.1 (VSS), U13.14 (VSS), U14.8 (GND), U14.15 (#EN), U15.2 (GND), U16.2 (GND), U17.4 (GND); also elsewhere on the board
unnamed: D4.1 (K), U13.12 (LED)
unnamed: D4.2 (A), R17.2
unnamed: R16.1, U13.11 (GPIO)
unnamed: R18.2, U15.1 (CH1)
unnamed: R19.2, U16.1 (CH1)

Notes on the sheet:
Flash
Switch
USB Interface

Schematic: Debugger.kicad_sch, MM32 Control Board

Parts:
C69: 10uF; C_0603_1608Metric
C70: 100nF; C_0603_1608Metric
M1: Debugger; Gernic_Debugger
R8: 10kR; R_0603_1608Metric
SW1: SW_DIP_x02; SW_DIP_SPSTx02_Slide_Copal_CHS-02B_W7.62mm_P1.27mm
U10: CH440R; TSSOP-16_4.4x5mm_P0.65mm

Connections:
+5V: C69.1, C70.1, M1.1 (5V), M1.8 (5V), R8.1, U10.16 (VCC); also elsewhere on the board
/Control_MCU/SWDCLK: U10.3 (S2A); also elsewhere on the board
/Control_MCU/SWDIO: U10.6 (S2B); also elsewhere on the board
/Control_MCU/UART1_RX: U10.13 (S2D); also elsewhere on the board
/Control_MCU/UART1_TX: U10.10 (S2C); also elsewhere on the board
/Debugger/DBG_RX: M1.6 (U_TX), U10.9 (DC)
/Debugger/DBG_RX1: U10.11 (S1C); also elsewhere on the board
/Debugger/DBG_TX: M1.7 (U_RX), U10.12 (DD)
/Debugger/DBG_TX1: U10.14 (S1D); also elsewhere on the board
/Debugger/SEL: R8.2, SW1.4, U10.1 (SEL)
/Debugger/SWDCLK: M1.3 (SWDCLK), U10.4 (DA)
/Debugger/SWDCLK1: U10.2 (S1A); also elsewhere on the board
/Debugger/SWDIO: M1.2 (SWDIO), U10.7 (DB)
/Debugger/SWDIO1: U10.5 (S1B); also elsewhere on the board
GND: C69.2, C70.2, M1.4 (GND), M1.5 (GND), SW1.1, U10.8 (GND), U10.15 (#EN); also elsewhere on the board

Notes on the sheet:
Debugger
Switch

Board: 4 copper layers, 95.0 x 50.0 mm, 128 parts (77 on the bottom side), 106 nets.

## KiCad design circuit/bldc_driver/project.kicad_pcb

Parts:
C1: 1uF; C_0603_1608Metric
C2, C3, C4: 10uF; C_0603_1608Metric
C7, C8: 100nF; C_0603_1608Metric
D1, D2: LED; LED_0603_1608Metric
J1: Conn_01x04; PinSocket_1x04_P2.54mm_Vertical
R1, R16, R17: 10kR; R_0603_1608Metric
R2, R3, R4, R5, R6, R7: 1kR; R_0603_1608Metric
R8, R9, R10, R11: 100kR; R_0603_1608Metric
R12: 47kR; R_0603_1608Metric
R13, R14: 2kR; R_0603_1608Metric
R15: 40kR; R_0603_1608Metric
U1: MM32SPIN360C; QFN-48-1EP_6x6mm_P0.4mm_EP4.2x4.2mm
U2: REF3025; SOT-23

Connections:
+2V5: R8.2, R9.2, U2.2 (OUT)
+5V: J1.1, R13.1, R14.1, R17.1, U1.3 (VDDIO), U1.9 (VDDA), U1.23 (VDDIO), U2.1 (VCC); also elsewhere on the board
+12V: U1.2 (VCC); also elsewhere on the board
+15V: R15.1; also elsewhere on the board
/Connector/HA: U1.10 (PA0); also elsewhere on the board
/Connector/HB: U1.11 (PA1); also elsewhere on the board
/Connector/HC: U1.12 (PA2); also elsewhere on the board
/Connector/NTC: U1.17 (PA7); also elsewhere on the board
/Controller/HO1: U1.47 (HO1); also elsewhere on the board
/Controller/HO2: U1.43 (HO2); also elsewhere on the board
/Controller/HO3: U1.39 (HO3); also elsewhere on the board
/Controller/IA: R4.2; also elsewhere on the board
/Controller/IB: R5.2; also elsewhere on the board
/Controller/ISUM: R2.2, R3.2, R7.2; also elsewhere on the board
/Controller/LO1: U1.45 (LO1); also elsewhere on the board
/Controller/LO2: U1.41 (LO2); also elsewhere on the board
/Controller/LO3: U1.37 (LO3); also elsewhere on the board
/Controller/PA3: C1.1, R1.2, U1.13 (PA3), U1.35 (PD3/CMP4_INP)
/Controller/PA4: R7.1, U1.14 (PA4/OP1_INP)
/Controller/PA5: R6.2, R12.2, U1.15 (PA5/OP1_INM)
/Controller/PA6: R1.1, R12.1, U1.16 (PA6/OP1_OUT)
/Controller/PB0: R4.1, R8.1, U1.18 (PB0/OP2_INP)
/Controller/PB1: R2.1, R10.2, U1.19 (PB1/OP2_INM)
/Controller/PB2: R10.1, U1.20 (PB2/OP2_OUT)
/Controller/PB10: R11.1, U1.21 (PB10/OP3_OUT)
/Controller/PB11: R3.1, R11.2, U1.22 (PB11/OP3_INM)
/Controller/PB12: R5.1, R9.1, U1.25 (PB12/OP3_INP)
/Controller/PB13: D1.1 (K), U1.26 (PB13)
/Controller/PB15: C8.1, R15.2, R16.1, U1.28 (PB15)
/Controller/RST: C7.1, R17.2, U1.8 (~RST)
/Controller/SWDCLK: J1.2, U1.36 (PA14/SWDCLK)
/Controller/SWDIO: J1.3, U1.33 (PA13/SWDIO)
/Controller/UART1_RX: U1.30 (PA10); also elsewhere on the board
/Controller/UART1_TX: U1.29 (PA9); also elsewhere on the board
/Controller/VS1: C2.2, U1.46 (VS1); also elsewhere on the board
/Controller/VS2: C3.2, U1.42 (VS2); also elsewhere on the board
/Controller/VS3: C4.2, U1.38 (VS3); also elsewhere on the board
GND: C1.2, C7.2, C8.2, D2.1 (K), J1.4, R6.1, R16.2, U1.1 (GND), U1.24 (GND), U1.49 (GND), U2.3 (GND); also elsewhere on the board
unnamed: C2.1, U1.48 (VB1)
unnamed: C3.1, U1.44 (VB2)
unnamed: C4.1, U1.40 (VB3)
unnamed: D1.2 (A), R13.2
unnamed: D2.2 (A), R14.2

Notes on the sheet:
Current Sample
LED
Microcontroller
Debug Port
RST

Parts:
C14: 100nF; C_0603_1608Metric
J5: GH1.25_6P; JST_GH_BM06B-GHS-TBT_1x06-1MP_P1.25mm_Vertical
R36: 10kR; R_0603_1608Metric
U4, U5, U6: 74HC1G126GW; SOT-353_SC-70-5

Connections:
+5V: J5.1, R36.1, U4.1 (OE), U4.5 (VCC), U5.1 (OE), U5.5 (VCC), U6.1 (OE), U6.5 (VCC); also elsewhere on the board
/Connector/HA: U4.4 (Y); also elsewhere on the board
/Connector/HB: U5.4 (Y); also elsewhere on the board
/Connector/HC: U6.4 (Y); also elsewhere on the board
/Connector/MHA: J5.3, U4.2 (A)
/Connector/MHB: J5.4, U5.2 (A)
/Connector/MHC: J5.5, U6.2 (A)
/Connector/NTC: C14.2, J5.2, R36.2; also elsewhere on the board
GND: C14.1, J5.6, U4.3 (GND), U5.3 (GND), U6.3 (GND); also elsewhere on the board

Notes on the sheet:
Motor Connector
