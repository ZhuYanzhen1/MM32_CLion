# Repository ZhuYanzhen1/MM32_CLion (continued)

## KiCad design circuit/project.kicad_pcb (continued)

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12: 100nF; C_0603_1608Metric
J1: ANT; SMA_Molex_73251-2200_Horizontal
L1: 39nH; L_0603_1608Metric
LCD1: 1.8inch-TFT-LCD; TFT-LCD1.8inch
U1: TAU1201; ublox_NEO
U2: XPT2046TS; TSSOP-16_4.4x5mm_P0.65mm

Connections:
+3.3VA: C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, LCD1.4 (LED+), LCD1.10 (VCC), LCD1.11 (IOVCC); also elsewhere on the board
+3.3VP: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, U1.22 (AVDD_BAK), U1.23 (VDD), U2.1 (VCC), U2.10 (IOVDD); also elsewhere on the board
/LCD&GPS/GPS_RX: U1.21 (UIN0); also elsewhere on the board
/LCD&GPS/GPS_TX: U1.20 (UOUT0); also elsewhere on the board
/LCD&GPS/LCD_A0: LCD1.7 (A0); also elsewhere on the board
/LCD&GPS/LCD_CLK: LCD1.9 (CLK); also elsewhere on the board
/LCD&GPS/LCD_CS: LCD1.12 (CS); also elsewhere on the board
/LCD&GPS/LCD_MOSI: LCD1.8 (DI); also elsewhere on the board
/LCD&GPS/LCD_RST: LCD1.6 (~RESET); also elsewhere on the board
/LCD&GPS/TOUCH_CLK: U2.16 (DCLK); also elsewhere on the board
/LCD&GPS/TOUCH_CS: U2.15 (~CS); also elsewhere on the board
/LCD&GPS/TOUCH_IT: U2.11 (~PENIRQ); also elsewhere on the board
/LCD&GPS/TOUCH_MISO: U2.12 (DOUT); also elsewhere on the board
/LCD&GPS/TOUCH_MOSI: U2.14 (DIN); also elsewhere on the board
/LCD&GPS/T_XM: LCD1.16 (X-), U2.4 (XN)
/LCD&GPS/T_XP: LCD1.18 (X+), U2.2 (XP)
/LCD&GPS/T_YM: LCD1.15 (Y-), U2.5 (YN)
/LCD&GPS/T_YP: LCD1.17 (Y+), U2.3 (YP)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, J1.2, LCD1.2 (GND), LCD1.3 (LED-), LCD1.5 (GND), LCD1.13 (GND), U1.10 (GND), U1.12 (GND), U1.13 (GND), U1.24 (GND), U2.6 (GND); also elsewhere on the board
unnamed: J1.1, L1.2, U1.11 (RF_IN)
unnamed: L1.1, U1.9 (ANT_BIAS)

Notes on the sheet:
GPS
LCD

Parts:
C52, C53, C55, C56, C57, C58, C60, C61, C62, C63, C64, C65, C66: 100nF; C_0603_1608Metric
C54, C59: 18pF; C_0603_1608Metric
D2: LED; LED_0603_1608Metric
R4, R6: 10kR; R_0603_1608Metric
R5: 1kR; R_0603_1608Metric
U11: MM32F3277G9P; LQFP-144_20x20mm_P0.5mm
Y2: 8MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3VP: C52.1, C53.1, C55.1, C56.1, C57.1, C58.1, C60.1, C61.1, C62.1, C63.1, C65.1, C66.1, R5.1, R6.1, U11.6 (VBAT), U11.17 (VDD), U11.32 (VREF+), U11.33 (VDDA), U11.39 (VDD), U11.52 (VDD), U11.62 (VDD), U11.72 (VDD), U11.84 (VDD), U11.95 (VDD), U11.108 (VDD), U11.121 (VDD), U11.131 (VDD), U11.144 (VDD); also elsewhere on the board
/Control_MCU/LED1: D2.1 (K), U11.1 (PE2)
/Control_MCU/RST: C64.1, R6.2, U11.25 (nRST)
/Control_MCU/SWDCLK: U11.109 (PA14); also elsewhere on the board
/Control_MCU/SWDIO: U11.105 (PA13); also elsewhere on the board
/Control_MCU/TIM3_CH1: U11.134 (PB4); also elsewhere on the board
/Control_MCU/UART1_RX: U11.102 (PA10); also elsewhere on the board
/Control_MCU/UART1_TX: U11.101 (PA9); also elsewhere on the board
/Control_MCU/UART6_RX: U11.47 (PB1); also elsewhere on the board
/Control_MCU/UART6_TX: U11.46 (PB0); also elsewhere on the board
/Control_MCU/UART7_RX: U11.137 (PB7); also elsewhere on the board
/Control_MCU/UART7_TX: U11.136 (PB6); also elsewhere on the board
/Control_MCU/XTAL_IN: C59.1, U11.23 (PH0), Y2.3
/Control_MCU/XTAL_OUT: C54.1, U11.24 (PH1), Y2.1
GND: C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, R4.1, U11.16 (VSS), U11.30 (VSSA), U11.31 (VREF-), U11.38 (VSS), U11.51 (VSS), U11.61 (VSS), U11.71 (VSS), U11.83 (VSS), U11.94 (VSS), U11.107 (VSS), U11.120 (VSS), U11.130 (VSS), U11.143 (VSS), Y2.2, Y2.4; also elsewhere on the board
unnamed: D2.2 (A), R5.2
unnamed: R4.2, U11.138 (PH3)

Notes on the sheet:
LED
XTAL & RST
Filter

Parts:
C69, C72, C73: 100nF; C_0603_1608Metric
C70: 220nF; C_0603_1608Metric
C71: 4.7uF; C_0603_1608Metric
R9, R10: 2.2kR; R_0603_1608Metric
U13: HMC5883L; QFN-16_3x3_Pitch0.5mm
U14: AT24C02; SOP-8_3.9x4.9mm_P1.27mm

Connections:
+3.3VP: C69.1, C72.1, C73.1, R9.1, R10.1, U13.2 (VDD), U13.4 (S1), U13.13 (VDDIO), U14.8 (VDD); also elsewhere on the board
/Compass&Storage/COMPASS_RDY: U13.15 (RDRY); also elsewhere on the board
/Compass&Storage/IIC_SCL: R10.2, U13.1 (SCL), U14.6 (SCL); also elsewhere on the board
/Compass&Storage/IIC_SDA: R9.2, U13.16 (SDA), U14.5 (SDA); also elsewhere on the board
GND: C69.2, C71.2, C72.2, C73.2, U13.9 (GND), U13.11 (GND), U14.1 (A0), U14.2 (A1), U14.3 (A2), U14.4 (GND), U14.7 (WP); also elsewhere on the board
unnamed: C70.1, U13.12 (SETC)
unnamed: C70.2, U13.8 (STEP)
unnamed: C71.1, U13.10 (C1)

Notes on the sheet:
EEPROM
Cmpass

Parts:
C67: 10uF; C_0603_1608Metric
C68: 100nF; C_0603_1608Metric
M1: Debugger; Gernic_Debugger
R7: 10kR; R_0603_1608Metric
SW1: SW_DIP_x02; SW_DIP_SPSTx02_Slide_Copal_CHS-02B_W7.62mm_P1.27mm
U12: CH440R; TSSOP-16_4.4x5mm_P0.65mm

Connections:
+5V: C67.1, C68.1, M1.1 (5V), M1.8 (5V), R7.1, U12.16 (VCC); also elsewhere on the board
/Control_MCU/SWDCLK: U12.3 (S2A); also elsewhere on the board
/Control_MCU/SWDIO: U12.6 (S2B); also elsewhere on the board
/Control_MCU/UART1_RX: U12.13 (S2D); also elsewhere on the board
/Control_MCU/UART1_TX: U12.10 (S2C); also elsewhere on the board
/Debugger/DBG_RX: M1.6 (U_TX), U12.9 (DC)
/Debugger/DBG_RX1: U12.11 (S1C); also elsewhere on the board
/Debugger/DBG_TX: M1.7 (U_RX), U12.12 (DD)
/Debugger/DBG_TX1: U12.14 (S1D); also elsewhere on the board
/Debugger/SEL: R7.2, SW1.4, U12.1 (SEL)
/Debugger/SWDCLK: M1.3 (SWDCLK), U12.4 (DA)
/Debugger/SWDCLK1: U12.2 (S1A); also elsewhere on the board
/Debugger/SWDIO: M1.2 (SWDIO), U12.7 (DB)
/Debugger/SWDIO1: U12.5 (S1B); also elsewhere on the board
GND: C67.2, C68.2, M1.4 (GND), M1.5 (GND), SW1.1, U12.8 (GND), U12.15 (#EN); also elsewhere on the board

Notes on the sheet:
Debugger
Switch

Board: 4 copper layers, 95.0 x 50.0 mm, 108 parts (65 on the bottom side), 76 nets.

## Code that names these connections

File program/user/pin.h:

/**************************************************************************/ /**
    \file     pin.h
    \brief    file that stores GPIO pin and port macros.
    \author   Lao·Zhu
    \version  V1.0.1
    \date     19. January 2022
 ******************************************************************************/

#ifndef MM32F3277_USER_PIN_H_
#define MM32F3277_USER_PIN_H_

#define LED1_PORT       GPIOA
#define LED1_PIN        GPIO_Pin_3

#define LCD_RES_PORT    GPIOF
#define LCD_RES_PIN     GPIO_Pin_0
#define LCD_A0_PORT     GPIOE
#define LCD_A0_PIN      GPIO_Pin_4
#define LCD_CSB_PORT    GPIOE
#define LCD_CSB_PIN     GPIO_Pin_3

#define TOUCH_CS_PORT   GPIOE
#define TOUCH_CS_PIN    GPIO_Pin_1
#define TOUCH_PEN_PORT  GPIOE
#define TOUCH_PEN_PIN   GPIO_Pin_0

#endif // MM32F3277_USER_PIN_H_

## Commit log (part)

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2022-03-19 Implementation of serial link layer protocols Joint debugging with ProcessMCU to ensure correct reading of accelerometer data and true north angle
2022-03-19 Routine commit
2022-03-19 Porting RT-Thread real-time operating system and adapting the code.
2022-03-19 Adding a gui to display the communication results between MCUs
2022-03-19 Divides the LCD display, key detection and LED flip into subtasks.
2022-03-20 Fixed GPS reception anomaly
2022-03-20 Fix GPS receive bug
2022-03-20 Modified the communication process between the coprocessor and the master and the unpackaging process
2022-03-20 Porting the unpacker from the master branch to the rt-thread
2022-03-20 Put all functions displayed with gui into gui_debug.c
2022-03-20 Add semaphores so that touch screen scanning is triggered by interrupts.
2022-03-20 Synchronize the gui display to the rt-thread branch
2022-03-20 Fixed the problem of fusion process creation failure Fixed the error of calculating distance by GPS latitude and longitude Added the function to calculate acos Bebug
2022-03-20 Modify the gui button's structure name to conform to google style.
2022-03-20 Move the coprocessor package decoding code segment to the sensor fusion thread.
2022-03-21 Add label widget to gui.
2022-03-21 Correction of the coordinate system transformation formula regarding distance
2022-03-21 Porting coordinate system transformations and inverse trigonometric functions to the rtthread branch
2022-03-21 Porting gui-related files from master to rtthread branch
2022-03-21 Porting fusion process in master to rtthread branch
2022-03-21 Change the GUI display to asynchronous execution.
2022-03-21 Add GUI text label alignment.
2022-03-21 Add GUI form update code
2022-03-21 Passes the touch detection values to the GUI process via a queue and adds process status detection code.
2022-03-21 Add newline code to the process monitoring function
2022-03-21 Modify the process stack size to avoid under-allocated memory.
2022-03-21 Modify the version of the tool and turn on the debug log.
2022-03-21 Complete the porting of touch detection in RT-Thread.
2022-03-21 Modify some conflicting parts in main.c
2022-03-21 Finish writing the touch key callback function logic.
2022-03-21 Separate the pages and finish writing the button callback functions.
2022-03-21 Complete the interaction between the touch screen detection thread and the GUI display thread.
2022-03-22 Porting the modified kalman fusion solution to rtthread
2022-03-22 Successful porting of the modified Kalman fusion scheme to rtthread
2022-03-22 Initialize uart_4
2022-03-22 Implemented communication between proc_mcu and ctrl_mcu
2022-03-22 Update some macro definitions inside ctrl_mcu
2022-03-22 Add true north angle after sending Kalman fusion in proc_mcu and ctrl_mcu communication
2022-03-22 Change ctrl_mcu's serial port reception to DMA double ping pong buffer reception
2022-03-23 ctrl_mcu send pwm to Power with timer 3 channel 1
2022-03-24 Modify the scheme of brushless motor driver board to reduce the use of resistors and capacitors to reduce the size of the circuit.
2022-03-25 Modify the code of the Riccati solver to split the matrix calculation to speed up.
2022-03-25 Testing riccati_solver
2022-03-25 Some components in the six-step commutation brushless drive were modified to achieve a smaller size.
2022-03-25 Update the latest unit test reports to Github Pages.
2022-03-25 Replace all floating point operations in riccati_solver with inline assembly
2022-03-25 Modify the Riccati equation solver back to the version that does not use the math library.
2022-03-25 Update the test code in the unit test about the Riccati solver. Modify the Github Page page.
2022-03-26 Ported the algorithm for geomagnetometer correction to the coprocessor and wrote the associated reception program in the procMCU
2022-03-26 Complete the design of BLDC Driver PCB and export the interactive BOM.
2022-03-27 Control coprocessor correction geomagnetometer with gui virtual key implementation Implementing flash read/write
2022-03-27 Add code to the update function of the gui label to clear a line of the screen, so that you don't need to clear the previous data by a space.
2022-03-27 Optimize tasks.
2022-03-27 Add calibration form
2022-03-27 gui Orgin Data
2022-03-27 Rearrange form directory.
2022-03-27 Complete the full functionality of the Touch Calibration window.
2022-03-27 gui Fusion
2022-03-27 Modify sensor_decode to solve more acceleration information of imu when solving variable number of packages
2022-03-27 Add calibrate and return button to mag calibrate form.
2022-03-28 Add the joystick remote control signal sending in the upper computer.
2022-03-28 Modify the main control board schematic, replace the IMU device and remove the isolation module.
2022-03-30 Optimize the minimum value point by dichotomy
2022-03-31 Optimizing the convergence speed of Newton's method for roots by Newton's downhill method
2022-04-06 Modify the ControlBoard schematic to add useful features.
2022-04-06 Update the ControlBoard's PCB and export the interactive BOM.
2022-04-06 Modified the BLDC driver circuit by deleting the crystal and adding decoupling capacitors. Replaced the buck chip with JW5017s chip for power supply.
2022-04-06 Completed PCB layout wiring of BLDC driver circuit and exported the interactive BOM.
2022-04-09 Further improve the communication between the brushless driver board and the control MCU
2022-04-10 Dichotomous reading point success Successful remote control test
2022-04-12 Add remote control related code
2022-04-13 Modified the communication between proc_mcu and ctrl_mcu
2022-04-15 Update control board schematic pdf file.
2022-04-16 Change the uart8 used to communicate with read_mcu from proc_mcu to uart2
2022-04-16 Add the DMA receive function of uart2 and restore the communication between proc_mcu and read_mcu
2022-04-17 Optimize the state machine of uart2 DMA receive read_mcu and fix the state that may be wrong
2022-04-17 Modified the parameters of Kalman Fusion
2022-04-17 Fix the problem that unit test does not have fflush function.
2022-04-18 debug...
2022-04-21 Finished reading and writing to the w25q32
2022-04-21 Updated the main control board circuit to change the GNSS feed line from microstrip line to ribbon line.
2022-04-22 Slightly modify the ControlBoard package
2022-04-22 Successfully solve the flash writing bug and complete the creation of the file system
2022-04-22 Changed Flash to 8MB capacity, and added new Flash test function.
2022-04-22 remove flash.h in main.h of proc_mcu
2022-04-22 Complete the file system write file test.
2022-04-22 Completed FATFS read file test and added FATFS file read and write test code.
2022-04-22 Solved the problem of GUI displaying data residuals and reformatted the code of the Riccati solver section.
2022-04-29 Fixed the problem that the status was not switched after exiting the magnetometer calibration page.
2022-05-02 Modify some of the code related to LQR control
2022-05-02 Adding a GUI interface for unit tests
2022-05-02 Modified the main control board schematic by deleting the extra wireframes.
2022-05-02 Remove useless arrays within unit tests
2022-05-02 Add code files for simulating tracks.
2022-05-02 Rewriting arrays of traces in unit tests to macros
2022-05-03 Center the track in unit test display.
2022-05-03 Improve LQR control within unit tests
2022-05-03 Added function to draw actual trajectory, not finished writing yet.
2022-05-03 Improve LQR control within unit tests and simplify the state update section
2022-05-03 Fixed a bug in LQR control
2022-05-04 Added ch372 initialization, but the communication timing is still problematic.
2022-05-04 Increase the program of braking after reaching the end
2022-05-07 Test GPS filtering effect
2022-05-07 Formatting the code to handle it neatly
2022-05-07 New track
2022-05-07 Prevents the timestamp from having a very large value.
2022-05-08 Fixed the judgment of GPS stability
2022-05-08 Modify CH372 timing, but still can't communicate with it.
2022-05-08 Tidy up the code and simplify unnecessary parts.
2022-05-11 Optimized the communication between read_mcu and proc_mcu, improving the use of instantaneous values instead of average values. optimized the communication between proc_mcu and ctrl_mcu to reduce the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
2022-05-12 Increase dynamic filtering coefficient
2022-05-13 Artificially modify the calculation of deviations in LQR
2022-05-13 Position and heading angle predictions have been added and the low-pass filtering of GPS positions has been removed.
2022-05-14 Removed low-pass filtering of GPS positions. Added low-pass filtering for GPS velocity
2022-05-15 Kalman filtering three statesvelocity
2022-05-17 Remove the geomagnetometer from the main control board to enable external connection of the geomagnetometer.
2022-05-18 Adding a forecasting process Fix transmission vulnerability
2022-05-18 Add circuit of geomagnetic meter
2022-05-18 Fixed a bug in communication between ProcessMCU and ControlMCU.
2022-05-18 Add automatic merge functionality to unit test scripts.
2022-05-20 LQR success!
2022-05-21 Change of playground track Speed up to 15000 rpm
2022-05-22 Added the function of automatically generating version number based on git.
2022-05-22 Print the firmware version number at power on.
2022-05-27 routine cimmit
2022-05-28 Complete the design of the geomagnetometer circuit and update the PCB rules.
2022-05-28 routine_commit
2022-05-29 LQR unit test
2022-05-29 Modify the code for solving the feedback gain matrix and change the input variables to double type to improve accuracy.
2022-05-29 Modifies the LQR iteration accuracy back to the original value.
2022-05-30 Added angle restrictions to the project section
2022-05-31 speed 15000 !!!
2022-06-08 fix: Fixed the problem that unit tests cannot be compiled.
2022-07-09 6.22
2022-07-09 Export the interactive BOM of the geomagnetometer circuit.
2022-07-09 Fixed part of the control board circuit and added SD card reading chip.
2022-07-11 Updated the main control board schematic and switched the geomagnetometer interface sequence.
2022-07-11 Complete the master board layout wiring and export the new interactive BOM.
2022-07-15 2w rad/min
2022-07-16 2w rad/min half path
2022-07-17 Add Low-Power warning to GUI
2022-07-17 Reduced control frequency of proc_mcu Replaced the trajectory (2w speed will rush into the grass)
2022-07-17 The file system read/write migration was successful. The function was removed because the scan for available space was taking too long.
2022-07-19 Add power board circuit to repo
2022-07-19 Add silkscreen and name to the geomagnetometer plate.
2022-07-19 Update the power board PCB file and complete the power board layout wiring.
2022-07-19 Modify the serial port used by the GPS to adapt to version 1.6.1 of the main control board.
2022-07-20 Added top speed statistics and displayed them on the GUI interface.
2022-07-20 2w .. path_8
2022-07-21 Reorganize the code
2022-07-21 Fixed some problems with unit test compilation.
2022-07-21 Increase the transfer rate of TF card SPI to read and write files faster.
2022-07-21 12m/s
2022-07-21 13m/s Not verified
2022-07-22 Update manufacturing documents related to mechanical structures.
2022-07-22 Add current statistics function
2022-07-23 add gitignore to ignore version file
2022-07-23 Add gui to display temperature
2022-07-23 Determine if the computer is connected at power on.
2022-07-23 Add pop-up stuck code.
2022-07-23 Solve the geomagnetometer angle problem that has been plaguing us.
2022-07-24 23000rad/min
2022-07-27 Add comment
2022-07-27 Modify the page of github page for classification. Modify Doxygen configuration file reads.
2022-07-28 Add comments about macros and variables
2022-07-30 Modified the comments in the ControlMCU interrupt callback function file
2022-07-30 Updated configuration file comments and removed useless peripheral initialization functions.
2022-07-30 Improve the comments of the code
2022-07-30 Add comments to pin.h
2022-07-30 Modify callback function in mm32f3x_it.h
