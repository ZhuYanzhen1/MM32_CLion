# Repository ZhuYanzhen1/MM32_CLion

File README.md:

# MM32_CLion

&nbsp;&nbsp;&nbsp;&nbsp;&nbsp;&nbsp;&nbsp;&nbsp;&nbsp;&nbsp;&nbsp;&nbsp;English / [中文](https://github.com/ZhuYanzhen1/MM32_CLion/blob/master/README_CN.md)

&nbsp;&nbsp;&nbsp;&nbsp;This project is a Windows CLion IDE file for the MM32F3277G9 chip and a circuit design for the main control board based on the MM32F3277G9 chip. The software code contains the link files required for GCC, CMake files, clang-format files, Doxygen configuration files, etc. to ensure that this package is ready to use when it arrives. The hardware mainly contains the schematic and PCB files, and the Gerber files will be released in the form of Releases.The adapted tuning tool is developed using Qt, and the repository contains the Qt source code files for the tool. Some Python scripting tools are also provided for easy development, such as scripts for calculating filter parameters.<br>
&nbsp;&nbsp;&nbsp;&nbsp;This project is developed around the 2022 National Student Intelligent Vehicle Competition. Complex algorithms such as LQR controller, multi-rate Kalman fusion, and advanced development tools such as unit testing and continuous integration are innovatively used in this project for development, which greatly improves the development efficiency and reduces the development cost.

***

### Develop Environment

+ Integrated Development Environment: CLion CL-221.5921.27
+ OS: Windows 10 Professional 21H2 x64 10.0.19044
+ Make tool: GNU Make 4.3 x86_64-w64-mingw32
+ Compiler tool chain: gcc-arm-none-eabi 10.3.1 20210824
+ Burning tool: OpenOCD 0.11.0+dev-00449-gb2ab2241f+ (2021-11-13-20:25)
+ Documentation tool: Doxygen GUI 1.9.4 (Qt version 5.15.2)
+ EDA tool: KiCAD 6.0.5 (VC++ 1929, 64bit)
+ Qt environment: Qt 5.14.2 (MSVC 2017, 32bit)
+ Python version: Python 3.10.5 [MSC v.1929 64 bit (AMD64)] on win32

***

### Directory Structure

+ .github: Configuration file for the continuous integration of Github Actions.
+ circuit: Schematics and PCB files related to the project.
  + bldc_driver: Schematic and PCB file of the brushless driver board.
  + control_board: Schematic and PCB file of the main control board.
  + geomagnetometer: Schematic and PCB file of geomagnetometer board.
  + power_board: Schematic and PCB file of the power supply board.
  + uart_tt_mcu: Schematic and PCB file of serial transmission module microcontroller side.
  + uart_tt_pc: Schematic and PCB file of the PC side of the serial port pass-through module.
  + wireless_debugger: Schematic and PCB file of the wireless debugger.
+ docs: html documents and related images and board interactive BOMs generated by Doxygen.
+ mechanical: 3D model files of non-standard mechanical parts.
  + battery_mount: 3D model file of the battery mount.
  + car_shell: 3D model file of the car shell.
  + control_board_mount: 3D model file of main control board and power board bracket.
  + magnometer_mount: 3D model file of geomagnetometer bracket.
+ program: Source file and configuration file of the main controller program.
  + ctrl_mcu: control MCU user layer code, main logic implementation.
  + debug: transmission layer code and CMBackTrace program file for implementing serial port tuning reference.
  + device: Device specific data link layer protocol to implement device level register read/write.
  + fatfs: code related to the FAT file system.
  + form: All form controls and form actions for the display.
  + freertos: code for the FreeRTOS real-time operating system.
  + gui: the relevant drawing functions and forms code implementation for the display.
  + hardware: initialization and read/write code related to MM32F3277G9P chip peripherals.
  + library: code for the HAL library of the MM32F3277G9P chip provided by MindMotion.
  + math: code and functions related to math calculation, such as checksum calculation, FFT, etc.
  + proc_mcu: Handling MCU user layer code, main logic implementation.
  + protocol: data link layer transmission protocol for [sdtp and mdtp](https://github.com/ZhuYanzhen1/CDTP).
  + system: initialization and operation code related to MM32F3277G9P system.
+ scripts: Python script files used to facilitate program testing and design.
+ testbench: CUnit library-based unit test code for testing functions.
+ tools: Qt tuning tool source code used for tuning parameters.

***

### License

**Affiliation：AcmeTech<br>
Author: Yanzhen Zhu, Guilin Zhao, Hanbing Lai<br>
Maintainer：Yanzhen Zhu, Guilin Zhao, 2208213223@qq.com, 1662568794@qq.com**

&nbsp;&nbsp;&nbsp;&nbsp;The source code is released under a [AGPL-3.0 License](https://github.com/ZhuYanzhen1/MM32_CLion/blob/master/LICENSE).The product has been tested under Windows 10 and Ubuntu 18.04 and 20.04. This is research code, expect that it changes often and any fitness for a particular purpose is disclaimed.

## KiCad design circuit/power_board/power_board.kicad_pcb

Parts:
J2: GH1.25_1x8; JST_GH_SM08B-GHS-TB_1x08-1MP_P1.25mm_Horizontal
J3: conn_1x3; PinSocket_1x03_P2.54mm_Vertical
J4: GH1.25_1X3; JST_GH_SM03B-GHS-TB_1x03-1MP_P1.25mm_Horizontal
J5: CONN_1X7; PinHeader_1x07_P2.54mm_Vertical
J6: XT30; AMASS_XT30UPB-F_1x02_P5.0mm_Vertical
J7: XT60; AMASS_XT60-M_1x02_P7.20mm_Vertical

Connections:
+5VA: J2.1 (5V), J5.6; also elsewhere on the board
+6V: J3.2 (VCC); also elsewhere on the board
+15V: J7.1 (BAT); also elsewhere on the board
/Connector/D0: J5.5; also elsewhere on the board
/Connector/D1: J5.4; also elsewhere on the board
/Connector/D2: J5.3; also elsewhere on the board
/Connector/D3: J5.2; also elsewhere on the board
/Connector/M_RX: J2.4 (M_RX), J4.1 (RX)
/Connector/M_TX: J2.5 (M_TX), J4.2 (TX)
/Connector/PWR_RX: J2.6 (UART2_TX); also elsewhere on the board
/Connector/PWR_TX: J2.7 (UART2_RX); also elsewhere on the board
/Connector/Servo_PWM: J2.2 (Servo), J3.1 (Servo)
GND: J2.3 (GND), J2.8 (GND), J3.3 (GND), J4.3 (GDN), J5.7, J6.2 (GND), J7.2 (GND); also elsewhere on the board
VCC: J6.1 (VCC); also elsewhere on the board

Notes on the sheet:
Remote
BAT
Servo
Motor
ControlBoard

Parts:
C1, C2, C3, C4, C5, C6, C7: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D3: LED; LED_0603_1608Metric
J1: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
R1, R2, R4, R5, R6: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R7, R8, R9: 1kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: MM32SPIN27PS; LQFP-64_10x10mm_P0.5mm

Connections:
+3V3: C3.2, C4.2, C5.2, C6.2, C7.2, J1.1, R1.2, R7.1, R8.1, R9.1, U1.13 (VDDA), U1.32 (VDD), U1.64 (VDD); also elsewhere on the board
+15V: R2.1; also elsewhere on the board
/Connector/D0: U1.20 (PA4); also elsewhere on the board
/Connector/D1: U1.19 (PD5); also elsewhere on the board
/Connector/D2: U1.18 (PD4); also elsewhere on the board
/Connector/D3: U1.17 (PA3); also elsewhere on the board
/Connector/PWR_RX: U1.24 (PC4); also elsewhere on the board
/Connector/PWR_TX: U1.25 (PC5); also elsewhere on the board
/Controller/ADC1: R6.1; also elsewhere on the board
/Controller/ADC2: R2.2, R3.1, U1.22 (PA6)
/Controller/Current: C2.1, R6.2, U1.21 (PA5)
/Controller/LED1: D2.1 (K), U1.38 (PC7)
/Controller/LED2: D3.1 (K), U1.37 (PC6)
/Controller/PA9: U1.42 (PA9); also elsewhere on the board
/Controller/PA10: U1.43 (PA10); also elsewhere on the board
/Controller/PA11: U1.44 (PA11); also elsewhere on the board
/Controller/RST: C1.1, R1.1, U1.7 (nRST)
/Controller/SWCLK: J1.2, U1.49 (PA14)
/Controller/SWDIO: J1.3, U1.46 (PA13)
GND: C1.2, C2.2, C3.1, C4.1, C5.1, C6.1, C7.1, D1.1 (K), J1.4, R3.2, R4.2, R5.2, U1.12 (VSSA), U1.31 (VSS), U1.63 (VSS); also elsewhere on the board
unnamed: D1.2 (A), R7.2
unnamed: D2.2 (A), R8.2
unnamed: D3.2 (A), R9.2
unnamed: R4.1, U1.60 (BOOT0)
unnamed: R5.1, U1.28 (PB2)

Notes on the sheet:
MCU
Filter
Debug
LEDs

Parts:
C8, C15, C18, C20, C30: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C9: 4.7uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C10, C11, C16, C26, C28, C32: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C12, C14, C17, C24: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C13: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C19, C23: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C21: 680pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C22: 39pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C25, C31: 470uF; CP_Radial_D6.3mm_P2.50mm
C27: 100uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C29: 47uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D4, D5: SD103AWS; D_SOD-323_HandSoldering
D6: 16V; D_SMB
D7: 18V; D_SMB
D8: SK104C; D_SMC
D9: LED; LED_0603_1608Metric
F1: Fuse; Fuse_1206_3216Metric
J8, J9: conn_1x1; PinSocket_1x01_P2.54mm_Vertical
L1: 4.7uH; IND-SMD_L4.6-W4.2_SMMS0420
L2: 2.2uH; L_10.4x10.4_H4.8
Q1: SS8050; SOT-23
Q2: ME85P03; TO-252-2
R10, R21: 100R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11: 100kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R13: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14: 3kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15: 4.7kR; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R16: 16kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17: 3mR; R_2512_6332Metric
R18: 10R; R_1206_3216Metric
R19: 18.8kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R20: 5kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R22: 18.7kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R23: 78.7kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R24: 71.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R25: 11kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R26: 4.7kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: KEY; SW_SPST_CK_RS282G05A3
U2: JW5017S; SOT-23-6
U3: INA180A2; SOT-23-5
U4: ETA7014; TSOT-23-6
U5: TPS54540; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm
U6: HX9193-3.3GB; SOT-23-5

Connections:
+3V3: R13.2, U6.5 (VOUT); also elsewhere on the board
+5V: C12.2, C13.2, C14.2, C16.2, C17.2, C25.1, C28.2, L1.2, R16.1, R19.2, R21.2, U3.5 (VS), U4.4 (IN), U6.1 (VIN), U6.3 (EN)
+5VA: C23.2, C24.2, C27.2, U4.3 (OUT); also elsewhere on the board
+6V: C29.2, C30.2, C31.1, L2.2, R24.2, R26.1; also elsewhere on the board
+15V: F1.1, R18.1; also elsewhere on the board
/Controller/ADC1: U3.1 (OUT); also elsewhere on the board
/Controller/PA9: D4.2 (A), R13.1; also elsewhere on the board
/Controller/PA10: R10.2; also elsewhere on the board
/Controller/PA11: U4.2 (EN); also elsewhere on the board
GND: C8.1, C9.1, C10.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.2, C27.1, C28.1, C29.1, C30.1, C31.2, C32.1, D7.1 (A1), D8.2 (A), D9.1 (K), J8.1, Q1.2 (E), R12.1, R14.1, R20.1, R23.1, R25.1, SW1.2, U2.2 (GND), U3.2 (GND), U4.6 (GND), U5.7 (GND), U5.9 (EP), U6.2 (GND); also elsewhere on the board
unnamed: C10.2, D4.1 (K), D5.1 (K), J9.1, SW1.1
unnamed: C11.1, L1.1, U2.6 (SW)
unnamed: C11.2, U2.1 (BST)
unnamed: C15.2, R18.2
unnamed: C19.2, R21.1, U4.5 (VCC)
unnamed: C21.2, R22.1
unnamed: C22.2, R22.2, U5.6 (COMP)
unnamed: C26.1, D8.1 (K), L2.1, U5.8 (SW)
unnamed: C26.2, U5.1 (BOOT)
unnamed: C32.2, U6.4 (NC)
unnamed: D5.2 (A), D6.1 (A1), Q1.3 (C), Q2.1 (G), R15.1
unnamed: D6.2 (A2), D7.2 (A2), F1.2, Q2.3 (S), R15.2
unnamed: D9.2 (A), R26.2
unnamed: Q1.1 (B), R10.1, R12.2
unnamed: Q2.2 (D), R17.2, U3.3 (+)
unnamed: R11.1, U2.4 (EN)
unnamed: R14.2, R16.2, U2.3 (FB)
unnamed: R19.1, R20.2, U4.1 (FB)
unnamed: R23.2, U5.4 (RT/CLK)
unnamed: R24.1, R25.2, U5.5 (FB)
VCC: C8.2, C9.2, C18.2, C20.2, R11.2, R17.1, U2.5 (VIN), U3.4 (-), U5.2 (VIN), U5.3 (EN); also elsewhere on the board

Notes on the sheet:
5V Protect
Servo Power
5V Power
Switch
3.3V Power

Board: 2 copper layers, 50.0 x 50.0 mm, 88 parts (9 on the bottom side), 52 nets.

## KiCad design circuit/geomagnetometer/geomagnetometer.kicad_pcb

Parts:
C1, C3: 10uF; C_0603_1608Metric
C2, C4: 1uF; C_0603_1608Metric
C5, C7: 4.7uF; C_0603_1608Metric
C6, C8: 100nF; C_0603_1608Metric
J1: Conn_01x06; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
R1: 33kR; R_0603_1608Metric
R2, R3, R4, R5, R6, R7: 121R; R_0603_1608Metric
R8: PN13101(Z); PN13101
R9, R10: PN13104(XY); PN13104
U1: RM3100_13156; QFN-28-1EP_4x4mm_P0.4mm_EP2.4x2.4mm

Connections:
+3.3VADC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, J1.6, U1.4 (AVDD), U1.14 (DVDD), U1.26 (DVDD)
/CLK: J1.2, U1.27 (SCLK)
/CS: J1.5, U1.3 (SSN)
/MISO: J1.3, U1.28 (MISO)
/MOSI: J1.4, U1.1 (MOSI)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, J1.1, R1.2, U1.2 (RES), U1.5 (AVSS), U1.19 (DVSS), U1.20 (RES), U1.22 (I2CEN), U1.29
unnamed: R1.1, U1.25 (REXT)
unnamed: R2.1, U1.6 (ZDRVP)
unnamed: R2.2, R8.2 (B), U1.7 (ZINP)
unnamed: R3.1, U1.9 (ZDRVN)
unnamed: R3.2, R8.1 (A), U1.8 (ZINN)
unnamed: R4.1, U1.10 (YDRVP)
unnamed: R4.2, R9.2 (B), U1.11 (YINP)
unnamed: R5.1, U1.13 (YDRVN)
unnamed: R5.2, R9.1 (A), U1.12 (YINN)
unnamed: R6.1, U1.15 (XDRVP)
unnamed: R7.1, U1.18 (XDRVN)
unnamed: R7.2, R10.1 (A), U1.17 (XINN)
unnamed: R6.2, R10.2 (B), U1.16 (XINP)

Notes on the sheet:
Compass
Filter
Connector

Board: 2 copper layers, 17.6 x 19.1 mm, 20 parts (0 on the bottom side), 19 nets.

## KiCad design circuit/control_board/project.kicad_pcb

Parts:
C39: 680uF; Cap_SinkBoard
C40: 10uF; C_0603_1608Metric
C41, C42, C43, C44, C45, C46, C48, C49, C52, C53: 100nF; C_0603_1608Metric
C47, C50, C51: 22uF; C_0603_1608Metric
J3: Conn_01x08; JST_PH_S8B-PH-K_1x08_P2.00mm_Horizontal
U6, U7, U8: HX9193; SOT-23-5

Connections:
+3.3VA: C50.1, C52.1, U7.5 (VOUT); also elsewhere on the board
+3.3VADC: C47.1, C48.1, U6.5 (VOUT); also elsewhere on the board
+3.3VP: C51.1, C53.1, U8.5 (VOUT); also elsewhere on the board
+5V: C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C49.1, J3.8, U6.1 (VIN), U6.3 (EN), U7.1 (VIN), U7.3 (EN), U8.1 (VIN), U8.3 (EN); also elsewhere on the board
/Control_MCU/TIM3_CH1: J3.7; also elsewhere on the board
/Control_MCU/UART7_RX: J3.4; also elsewhere on the board
/Control_MCU/UART7_TX: J3.5; also elsewhere on the board
/Power/PWR_RX: J3.2; also elsewhere on the board
/Power/PWR_TX: J3.3; also elsewhere on the board
GND: C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, J3.1, J3.6, U6.2 (GND), U7.2 (GND), U8.2 (GND); also elsewhere on the board

Notes on the sheet:
Power Connector
3.3V Power Supply

Parts:
C24, C25, C27, C28, C29, C30, C32, C33, C34, C35, C36, C37, C38: 100nF; C_0603_1608Metric
C26, C31: 18pF; C_0603_1608Metric
D1: LED; LED_0603_1608Metric
R2, R4: 10kR; R_0603_1608Metric
R3: 1kR; R_0603_1608Metric
U5: MM32F3277G9P; LQFP-144_20x20mm_P0.5mm
Y1: 8MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3VA: C24.1, C25.1, C27.1, C28.1, C29.1, C30.1, C32.1, C33.1, C34.1, C35.1, C37.1, C38.1, R3.1, R4.1, U5.6 (VBAT), U5.17 (VDD), U5.32 (VREF+), U5.33 (VDDA), U5.39 (VDD), U5.52 (VDD), U5.62 (VDD), U5.72 (VDD), U5.84 (VDD), U5.95 (VDD), U5.108 (VDD), U5.121 (VDD), U5.131 (VDD), U5.144 (VDD); also elsewhere on the board
/Compass&Storage/EEPROM_SCL: U5.79 (PD10); also elsewhere on the board
/Compass&Storage/EEPROM_SDA: U5.80 (PD11); also elsewhere on the board
/Control_MCU/UART6_RX: U5.34 (PA0); also elsewhere on the board
/Control_MCU/UART6_TX: U5.35 (PA1); also elsewhere on the board
/Coprocessor/UART1_RX: U5.36 (PA2); also elsewhere on the board
/Coprocessor/UART1_TX: U5.37 (PA3); also elsewhere on the board
/Debugger/DBG_RX1: U5.101 (PA9); also elsewhere on the board
/Debugger/DBG_TX1: U5.102 (PA10); also elsewhere on the board
/Debugger/SWDCLK1: U5.109 (PA14); also elsewhere on the board
/Debugger/SWDIO1: U5.105 (PA13); also elsewhere on the board
/LCD&GPS/GPS_RX: U5.77 (PD8); also elsewhere on the board
/LCD&GPS/GPS_TX: U5.78 (PD9); also elsewhere on the board
/LCD&GPS/LCD_A0: U5.142 (PE1); also elsewhere on the board
/LCD&GPS/LCD_CLK: U5.118 (PD4); also elsewhere on the board
/LCD&GPS/LCD_CS: U5.123 (PD7); also elsewhere on the board
/LCD&GPS/LCD_MOSI: U5.122 (PD6); also elsewhere on the board
/LCD&GPS/LCD_RST: U5.141 (PE0); also elsewhere on the board
/LCD&GPS/TOUCH_CLK: U5.1 (PE2); also elsewhere on the board
/LCD&GPS/TOUCH_CS: U5.2 (PE3); also elsewhere on the board
/LCD&GPS/TOUCH_IT: U5.3 (PE4); also elsewhere on the board
/LCD&GPS/TOUCH_MISO: U5.4 (PE5); also elsewhere on the board
/LCD&GPS/TOUCH_MOSI: U5.5 (PE6); also elsewhere on the board
/Power/PWR_RX: U5.46 (PB0); also elsewhere on the board
/Power/PWR_TX: U5.47 (PB1); also elsewhere on the board
/Process_MCU/LED1: D1.1 (K), U5.40 (PA4)
/Process_MCU/RST: C36.1, R4.2, U5.25 (nRST)
/Process_MCU/XTAL_IN: C31.1, U5.23 (PH0), Y1.3
/Process_MCU/XTAL_OUT: C26.1, U5.24 (PH1), Y1.1
GND: C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, R2.1, U5.16 (VSS), U5.30 (VSSA), U5.31 (VREF-), U5.38 (VSS), U5.51 (VSS), U5.61 (VSS), U5.71 (VSS), U5.83 (VSS), U5.94 (VSS), U5.107 (VSS), U5.120 (VSS), U5.130 (VSS), U5.143 (VSS), Y1.2, Y1.4; also elsewhere on the board
unnamed: D1.2 (A), R3.2
unnamed: R2.2, U5.138 (PH3)

Notes on the sheet:
LED
XTAL & RST
Filter

Parts:
C13, C14, C16, C17, C18, C19, C20, C21, C22, C23: 100nF; C_0603_1608Metric
C15: 2.2nF; C_0603_1608Metric
U3: MPU-6050; InvenSense_QFN-24_4x4mm_P0.5mm
U4: ADXL350BCEZ; LGA-16-3.35mm_3.53mm

Connections:
+3.3VADC: C14.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, U3.8 (VDDIO), U3.13 (VDD), U4.1 (VDDIO), U4.14 (VS); also elsewhere on the board
/Coprocessor/IIC_CLK: U3.23 (SCL); also elsewhere on the board
/Coprocessor/IIC_SDA: U3.24 (SDA); also elsewhere on the board
/Coprocessor/PC6: U3.12 (INT); also elsewhere on the board
/Coprocessor/PC7: U4.11 (INT1); also elsewhere on the board
/Coprocessor/SPI2_CLK: U4.4 (CLK); also elsewhere on the board
/Coprocessor/SPI2_MISO: U4.7 (MISO); also elsewhere on the board
/Coprocessor/SPI2_MOSI: U4.6 (MOSI); also elsewhere on the board
/Coprocessor/SPI2_NSS: U4.8 (~CS); also elsewhere on the board
GND: C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, U3.1 (CLKIN), U3.9 (AD0), U3.18 (GND), U3.25, U4.13 (GND), U4.16 (GND); also elsewhere on the board
unnamed: C13.1, U3.10 (REGOUT)
unnamed: C15.1, U3.20 (CPOUT)

Notes on the sheet:
IMU
Filter

Notices in the files:
README.md:
License: AGPL
