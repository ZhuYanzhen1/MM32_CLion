# Repository ZhuYanzhen1/MM32_CLion (continued)

## KiCad design circuit/bldc_driver/project.kicad_pcb (continued)

Parts:
J4: MR30; MR30_Vertical
Q1, Q2, Q3, Q4, Q5, Q6: CSD18540Q5B; TDSON-8-1
R21, R22, R26, R27, R32, R33: 33R; R_0603_1608Metric
R23, R24, R28, R29, R34, R35: 10kR; R_0603_1608Metric
R25, R30, R31: 2mR; R_1206_3216Metric

Connections:
+15V: Q1.5 (D), Q3.5 (D), Q5.5 (D); also elsewhere on the board
/Controller/HO1: R32.1; also elsewhere on the board
/Controller/HO2: R26.1; also elsewhere on the board
/Controller/HO3: R21.1; also elsewhere on the board
/Controller/IA: Q6.1 (S), Q6.2 (S), Q6.3 (S), R25.2; also elsewhere on the board
/Controller/IB: Q4.1 (S), Q4.2 (S), Q4.3 (S), R31.2; also elsewhere on the board
/Controller/ISUM: Q2.1 (S), Q2.2 (S), Q2.3 (S), R24.1, R25.1, R29.1, R30.2, R31.1; also elsewhere on the board
/Controller/LO1: R33.1; also elsewhere on the board
/Controller/LO2: R27.1; also elsewhere on the board
/Controller/LO3: R22.1; also elsewhere on the board
/Controller/VS1: J4.3, Q5.1 (S), Q5.2 (S), Q5.3 (S), Q6.5 (D), R34.1; also elsewhere on the board
/Controller/VS2: J4.2, Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.5 (D), R28.1; also elsewhere on the board
/Controller/VS3: J4.1, Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.5 (D), R23.1; also elsewhere on the board
GND: R30.1, R35.1; also elsewhere on the board
unnamed: Q1.4 (G), R21.2, R23.2
unnamed: Q2.4 (G), R22.2, R24.2
unnamed: Q3.4 (G), R26.2, R28.2
unnamed: Q4.4 (G), R27.2, R29.2
unnamed: Q5.4 (G), R32.2, R34.2
unnamed: Q6.4 (G), R33.2, R35.2

Notes on the sheet:
MOSFET

Parts:
C5: 4.7uF; C_0603_1608Metric
C6, C15: 1uF; C_0603_1608Metric
C9, C12: 10uF; C_1206_3216Metric
C10, C13: 47uF; C_1206_3216Metric
C11: 100nF; C_0603_1608Metric
J2: XT30; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J3: GH1.25-3P; JST_GH_SM03B-GHS-TB_1x03-1MP_P1.25mm_Horizontal
L1: 4.7uH; L_Bourns-SRN4018
R18: 100kR; R_0603_1608Metric
R19: 140kR; R_0603_1608Metric
R20: 10kR; R_0603_1608Metric
U3: JW5015s; SOT-23-6

Connections:
+5V: C6.2, C15.2; also elsewhere on the board
+12V: C5.2, C12.2, C13.2, L1.2, R19.1; also elsewhere on the board
+15V: C9.2, C10.2, J2.2, R18.1, U3.5 (VIN); also elsewhere on the board
/Controller/UART1_RX: J3.2; also elsewhere on the board
/Controller/UART1_TX: J3.1; also elsewhere on the board
GND: C5.1, C6.1, C9.1, C10.1, C12.1, C13.1, C15.1, J2.1, J3.3, R20.2, U3.2 (GND); also elsewhere on the board
unnamed: C11.1, U3.1 (BST)
unnamed: C11.2, L1.1, U3.6 (SW)
unnamed: R18.2, U3.4 (EN)
unnamed: R19.2, R20.1, U3.3 (FB)

Notes on the sheet:
Power Supply

Board: 4 copper layers, 30.0 x 40.0 mm, 71 parts (42 on the bottom side), 56 nets.

## KiCad design circuit/uart_tt_mcu/project.kicad_pcb

Parts:
C1, C3, C4: 100nF; C_0603_1608Metric
C2: 10uF; C_0603_1608Metric
J1: Conn_02x04_Odd_Even; PinHeader_2x04_P1.27mm_Vertical_SMD
P1: USB_C_Plug_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
R1, R2, R3, R4: 10kR; R_0603_1608Metric
U1: E220-900T22S
U2, U3: RS0101YH6; SOT-23-6
U4: HX9193; SOT-23-5
U5: CH330N; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C2.1, C3.1, R1.1, R3.1, U1.25 (VCC), U2.1 (VCCA), U3.1 (VCCA), U4.5 (VOUT)
+5V: C1.1, J1.1, J1.2, P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS), U2.5 (OE), U2.6 (VCCB), U3.5 (OE), U3.6 (VCCB), U4.1 (VIN), U4.3 (EN), U5.5 (VCC)
/U0_RXD: U2.4 (B), U5.6 (TXD)
/U0_TXD: U3.4 (B), U5.7 (RXD)
/USB_DM: P1.A7 (D-), P1.B7 (D-), U5.2 (UD-)
/USB_DP: P1.A6 (D+), P1.B6 (D+), U5.1 (UD+)
/U_RXD: J1.5, U1.22 (RXD), U2.3 (A)
/U_TXD: J1.3, U1.23 (TXD), U3.3 (A)
GND: C1.2, C2.2, C3.2, C4.2, J1.7, J1.8, P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), R2.1, R4.1, U1.2 (GND), U1.8 (GND), U1.11 (GND), U1.13 (GND), U1.14 (GND), U1.15 (GND), U1.16 (GND), U1.19 (GND), U1.26 (GND), U2.2 (GND), U3.2 (GND), U4.2 (GND), U5.3 (GND)
unnamed: C4.1, U5.8 (V3)
unnamed: R3.2, R4.2, U1.20 (M0)
unnamed: R1.2, R2.2, U1.21 (M1)

Notes on the sheet:
E220-900T22S
USB TO TTL
PWR

Board: 2 copper layers, 40.0 x 20.0 mm, 15 parts (5 on the bottom side), 12 nets.

## KiCad design circuit/wireless_debugger/ESP8266.kicad_pcb

Parts:
C1: 10uF; C_0603_1608Metric
C2: 2.4pF; C_0603_1608Metric
C3, C5, C6, C8, C9, C12, C13, C14, C15, C16, C17: 100nF; C_0603_1608Metric
C4: 1uF; C_0603_1608Metric
C7: 3.0pF; C_0603_1608Metric
C10, C11: 18pF; C_0603_1608Metric
D1: LED; LED_0603_1608Metric
J1: Conn_02x04_Odd_Even; PinHeader_2x04_P1.27mm_Vertical_SMD
J2: Conn_01x03; IPEX 1G
K1, K2: SW_DIP_x01; SW_Push_SPST_NO_Alps_SKRK
L1: 2.2nH; L_0603_1608Metric
P1: USB_C_Plug_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
R1: 1kR; R_0603_1608Metric
R2, R4, R5, R6, R9, R10: 10kR; R_0603_1608Metric
R3: 12kR; R_0603_1608Metric
R7: 200R; R_0603_1608Metric
R8: 499R; R_0603_1608Metric
U1: W25Q64; SOIC-8_5.23x5.23mm_P1.27mm
U2: ESP8266EX; ESP8266
U3: HX9193; SOT-23-5
U4: CH330N; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 26MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3V3: C1.1, C3.1, C4.1, C5.1, C6.1, C9.1, C12.1, C13.1, C15.1, R2.1, R5.2, R6.2, R9.2, R10.2, U1.8 (VCC), U2.1 (VDDA), U2.3 (VDD3P3), U2.4 (VDD3P3), U2.11 (VDDPST), U2.17 (VDDPST), U2.29 (VDDD), U2.30 (VDDA), U3.5 (VOUT)
+5V: C14.1, J1.1, J1.2, P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS), U3.1 (VIN), U3.3 (EN), U4.5 (VCC)
/LED: R1.2, R4.2, U2.13 (MTDO)
/RST: C17.1, K2.2, R9.1, U2.32 (EXT_RSTB)
/SD_CLK: R7.2, U1.6 (CLK)
/SD_CMD: U1.1 (~CS), U2.20 (SD_CMD)
/SD_DATA0: U1.2 (DO(IO1)), U2.22 (SD_DATA0)
/SD_DATA1: U1.5 (DI(IO0)), U2.23 (SD_DATA1)
/SD_DATA2: U1.7 (IO3), U2.18 (SD_DATA2)
/SD_DATA3: U1.3 (IO2), U2.19 (SD_DATA3)
/SWDCLK: J1.6, U2.9 (MTMS)
/SWDIO: J1.4, U2.12 (MTCK)
/U0_RXD: J1.5, U2.25 (U0RXD), U4.6 (TXD)
/U0_TXD: R8.2, U4.7 (RXD)
/UART_TX: J1.3, R10.1, U2.14 (GPIO2)
/USB_DM: P1.A7 (D-), P1.B7 (D-), U4.2 (UD-)
/USB_DP: P1.A6 (D+), P1.B6 (D+), U4.1 (UD+)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, D1.1 (K), J1.7, J1.8, J2.1, J2.2, K1.1, K2.1, P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), R3.1, R4.1, U1.4 (GND), U2.33 (GND), U3.2 (GND), U4.3 (GND), Y1.2, Y1.4
unnamed: C2.1, J2.3, L1.1
unnamed: C7.1, L1.2, U2.2 (LNA)
unnamed: C8.1, R2.2, U2.7 (CHIP_EN)
unnamed: C10.1, U2.28 (XTAL_IN), Y1.1
unnamed: C11.1, U2.27 (XTAL_OUT), Y1.3
unnamed: C16.1, U4.8 (V3)
unnamed: D1.2 (A), R1.1
unnamed: K1.2, R5.1, U2.15 (GPIO0)
unnamed: R3.2, U2.31 (RES12K)
unnamed: R6.1, R8.1, U2.26 (U0TXD)
unnamed: R7.1, U2.21 (SD_CLK)

Notes on the sheet:
ESP8266 & FLASH
PWR&RST
USB TO TTL

Board: 2 copper layers, 40.0 x 20.0 mm, 39 parts (5 on the bottom side), 29 nets.

## KiCad design circuit/project.kicad_pcb

Parts:
C45, C46: 10uF; C_0603_1608Metric
C47, C49, C51: 100nF; C_0603_1608Metric
C48, C50: 22uF; C_0603_1608Metric
J2: Conn_01x08; JST_PH_S8B-PH-K_1x08_P2.00mm_Horizontal
U9, U10: HX9193; SOT-23-5

Connections:
+3.3VA: C48.1, C49.1, U9.5 (VOUT); also elsewhere on the board
+3.3VP: C50.1, C51.1, U10.5 (VOUT); also elsewhere on the board
+5V: C45.1, C46.1, C47.1, J2.8, U9.1 (VIN), U9.3 (EN), U10.1 (VIN), U10.3 (EN); also elsewhere on the board
/Control_MCU/TIM3_CH1: J2.7; also elsewhere on the board
/Control_MCU/UART7_RX: J2.4; also elsewhere on the board
/Control_MCU/UART7_TX: J2.5; also elsewhere on the board
/Power/PWR_RX: J2.2; also elsewhere on the board
/Power/PWR_TX: J2.3; also elsewhere on the board
GND: C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, J2.1, J2.6, U9.2 (GND), U10.2 (GND); also elsewhere on the board

Notes on the sheet:
Power Connector
3.3V Power Supply

Parts:
C30, C31, C33, C34, C35, C36, C38, C39, C40, C41, C42, C43, C44: 100nF; C_0603_1608Metric
C32, C37: 18pF; C_0603_1608Metric
D1: LED; LED_0603_1608Metric
R1, R3: 10kR; R_0603_1608Metric
R2: 1kR; R_0603_1608Metric
U8: MM32F3277G9P; LQFP-144_20x20mm_P0.5mm
Y1: 8MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3VA: C30.1, C31.1, C33.1, C34.1, C35.1, C36.1, C38.1, C39.1, C40.1, C41.1, C43.1, C44.1, R3.1, U8.6 (VBAT), U8.17 (VDD), U8.32 (VREF+), U8.33 (VDDA), U8.39 (VDD), U8.52 (VDD), U8.62 (VDD), U8.72 (VDD), U8.84 (VDD), U8.95 (VDD), U8.108 (VDD), U8.121 (VDD), U8.131 (VDD), U8.144 (VDD); also elsewhere on the board
+3.3VP: R2.1; also elsewhere on the board
/Compass&Storage/COMPASS_RDY: U8.81 (PD12); also elsewhere on the board
/Compass&Storage/IIC_SCL: U8.79 (PD10); also elsewhere on the board
/Compass&Storage/IIC_SDA: U8.80 (PD11); also elsewhere on the board
/Control_MCU/UART6_RX: U8.34 (PA0); also elsewhere on the board
/Control_MCU/UART6_TX: U8.35 (PA1); also elsewhere on the board
/Debugger/DBG_RX1: U8.101 (PA9); also elsewhere on the board
/Debugger/DBG_TX1: U8.102 (PA10); also elsewhere on the board
/Debugger/SWDCLK1: U8.109 (PA14); also elsewhere on the board
/Debugger/SWDIO1: U8.105 (PA13); also elsewhere on the board
/IMU/IMU_CLK: U8.118 (PD4); also elsewhere on the board
/IMU/IMU_CS: U8.123 (PD7); also elsewhere on the board
/IMU/IMU_DR: U8.125 (PG10); also elsewhere on the board
/IMU/IMU_MISO: U8.119 (PD5); also elsewhere on the board
/IMU/IMU_MOSI: U8.122 (PD6); also elsewhere on the board
/IMU/IMU_RST: U8.124 (PG9); also elsewhere on the board
/LCD&GPS/GPS_RX: U8.77 (PD8); also elsewhere on the board
/LCD&GPS/GPS_TX: U8.78 (PD9); also elsewhere on the board
/LCD&GPS/LCD_A0: U8.3 (PE4); also elsewhere on the board
/LCD&GPS/LCD_CLK: U8.1 (PE2); also elsewhere on the board
/LCD&GPS/LCD_CS: U8.2 (PE3); also elsewhere on the board
/LCD&GPS/LCD_MOSI: U8.5 (PE6); also elsewhere on the board
/LCD&GPS/LCD_RST: U8.10 (PF0); also elsewhere on the board
/LCD&GPS/TOUCH_CLK: U8.133 (PB3); also elsewhere on the board
/LCD&GPS/TOUCH_CS: U8.141 (PE0); also elsewhere on the board
/LCD&GPS/TOUCH_IT: U8.142 (PE1); also elsewhere on the board
/LCD&GPS/TOUCH_MISO: U8.134 (PB4); also elsewhere on the board
/LCD&GPS/TOUCH_MOSI: U8.135 (PB5); also elsewhere on the board
/Power/PWR_RX: U8.46 (PB0); also elsewhere on the board
/Power/PWR_TX: U8.47 (PB1); also elsewhere on the board
/Process_MCU/LED1: D1.1 (K), U8.37 (PA3)
/Process_MCU/RST: C42.1, R3.2, U8.25 (nRST)
/Process_MCU/XTAL_IN: C37.1, U8.23 (PH0), Y1.3
/Process_MCU/XTAL_OUT: C32.1, U8.24 (PH1), Y1.1
GND: C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, R1.1, U8.16 (VSS), U8.30 (VSSA), U8.31 (VREF-), U8.38 (VSS), U8.51 (VSS), U8.61 (VSS), U8.71 (VSS), U8.83 (VSS), U8.94 (VSS), U8.107 (VSS), U8.120 (VSS), U8.130 (VSS), U8.143 (VSS), Y1.2, Y1.4; also elsewhere on the board
unnamed: D1.2 (A), R2.2
unnamed: R1.2, U8.138 (PH3)

Notes on the sheet:
LED
XTAL & RST
Filter

Parts:
C13, C14, C15: 10uF; C_0603_1608Metric
C16, C17, C18, C19, C20, C21, C22, C24, C25, C26, C27, C28, C29: 100nF; C_0603_1608Metric
C23: 22uF; C_0603_1608Metric
L2: 6.8uH; L_Abracon_ASPI-0630LR
R8: 10kR; R_0603_1608Metric
U3: ADIS16470AMLZ
U4: B0505S-1WR3; SIP-4_B0505S_1WR3
U5: HX9193; SOT-23-5
U6, U7: π131M31; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+3.3VA: C26.1, C27.1, U6.1 (VDD1), U7.1 (VDD1); also elsewhere on the board
+3.3VADC: C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C28.1, C29.1, U3.C7 (VDD), U3.D6 (VDD), U3.E3 (VDD), U3.H1 (VDD), U3.J4 (VDD), U3.J5 (VDD), U3.K6 (VDD), U5.5 (VOUT), U6.16 (VDD2), U7.16 (VDD2)
+5V: C13.1, L2.1; also elsewhere on the board
+5VA: C15.1, C16.1, U4.4 (VDD2), U5.1 (VIN), U5.3 (EN)
/IMU/CS: U3.G3 (CS), U6.14 (OUT_A)
/IMU/DIN: U3.G6 (DIN), U7.13 (OUT_B)
/IMU/DOUT: U3.H3 (DOUT), U7.12 (IN_C)
/IMU/DR: U3.J6 (DR), U6.12 (IN_C)
/IMU/IMU_CLK: U7.3 (IN_A); also elsewhere on the board
/IMU/IMU_CS: U6.3 (IN_A); also elsewhere on the board
/IMU/IMU_DR: U6.5 (OUT_C); also elsewhere on the board
/IMU/IMU_MISO: U7.5 (OUT_C); also elsewhere on the board
/IMU/IMU_MOSI: U7.4 (IN_B); also elsewhere on the board
/IMU/IMU_RST: U6.4 (IN_B); also elsewhere on the board
/IMU/RST: U3.F3 (RST), U6.13 (OUT_B)
/IMU/SCLK: U3.H6 (SCLK), U7.14 (OUT_A)
GND: C13.2, C14.2, C26.2, C27.2, R8.1, U4.1 (GND1), U6.2 (GND1), U6.8 (GND1), U7.2 (GND1), U7.8 (GND1); also elsewhere on the board
GNDA: C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C28.2, C29.2, R8.2, U3.A1 (GND), U3.A2 (GND), U3.A3 (GND), U3.A4 (GND), U3.A5 (GND), U3.A6 (GND), U3.A7 (GND), U3.A8 (GND), U3.B3 (GND), U3.B4 (GND), U3.B5 (GND), U3.B6 (GND), U3.C2 (GND), U3.C6 (GND), U3.D3 (GND), U3.E2 (GND), U3.E6 (GND), U3.E7 (GND), U3.F1 (GND), U3.F6 (GND), U3.F8 (GND), U3.G2 (GND), U3.G7 (GND), U3.H8 (GND), U3.J2 (GND), U3.J7 (GND), U3.K1 (GND), U3.K3 (GND), U3.K8 (GND), U4.3 (GND2), U5.2 (GND), U6.9 (GND2), U6.15 (GND2), U7.9 (GND2), U7.15 (GND2)
unnamed: C14.1, L2.2, U4.2 (VDD1)

Notes on the sheet:
Power Supply Isolation
IMU
Filter
Signal Isolation
