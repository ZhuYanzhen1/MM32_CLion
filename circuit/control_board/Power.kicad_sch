File: circuit/control_board/Power.kicad_sch (KiCad schematic)
At the start: 13 parts, among them J2 Conn_01x08, U4 HX9193, U7 HX9193, U8 HX9193

Commit message: Fixed part of the control board circuit and added SD card reading chip.
Parts:
- renumbered C41 to C39, C42 to C40, C43 to C41, C22 to C42, C23 to C43, C46 to C45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
