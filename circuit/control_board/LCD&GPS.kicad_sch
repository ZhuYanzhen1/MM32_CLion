File: circuit/control_board/LCD&GPS.kicad_sch (KiCad schematic)
At the start: 19 parts, among them J1 ANT, J4 BAT_CR1220, U1 TAU1201, U2 XPT2046TS

Commit message: Modified the main control board schematic by deleting the extra wireframes.
Other:
- note removed: "Flash"
- moved on the sheet: C1, C10, C11, C12, C2, C3, C4, C5, C6, C7, C8, C9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
